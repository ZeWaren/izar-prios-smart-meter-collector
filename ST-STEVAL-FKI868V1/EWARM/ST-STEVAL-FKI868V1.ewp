# IAR project ST-STEVAL-FKI868V1.ewp, settings and files
configuration ST-STEVAL-FKI868V1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0XX_NUCLEO; USE_SYSTICK_DELAY
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/S2LP_Middleware/inc; ../Drivers/S2LP_Library/inc; ../Drivers/Utils/inc; ../Drivers/BSP/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ST-STEVAL-FKI868V1.hex
  ILINK.IlinkOutputFile: ST-STEVAL-FKI868V1.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c PRIOS.c S2LP_WMBus.c stm32l0xx_hal_msp.c stm32l0xx_it.c WMBus.c
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c
  group Drivers/BSP
    ../Drivers/BSP/src/: SDK_EVAL_Com_DMA.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/S2LP_Library
    ../Drivers/S2LP_Library/src/: S2LP_Commands.c S2LP_Fifo.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Types.c
  group Drivers/S2LP_Middleware
    ../Drivers/S2LP_Middleware/src/FEM/: S2LP_AUX_FEM_AUTO.c
    ../Drivers/S2LP_Middleware/src/: S2LP_AUX_UTILS.c S2LP_CORE_GPIO.c S2LP_CORE_SPI.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/Utils
    ../Drivers/Utils/src/: SDK_UTILS_Timers.c
